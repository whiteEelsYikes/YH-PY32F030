# Keil uVision project DCHEM_PID.uvprojx, settings and files
target DCHEM_PID (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.1.7
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DCHEM_PID.axf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\CMSIS\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\User;..\FreeRTOS-Kernel;..\FreeRTOS-Kernel\include;..\FreeRTOS-Kernel\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group starts
    ../Drivers/CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f030xx.s
    ../User/: system_py32f0xx.c
  group user
    ../User/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
    ../User/status_lights/: led.c
    ../User/oled/: OLED.c OLED_Data.c
    ../User/hall_encoder/: encoder.c
    ../User/mpu6050/: MPU6050.c
    ../User/motor_drive/: at8236x_motor.c
    ../User/usart/: usart.c
    ../User/sg90_servos/: sg90.c
  group hal
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group free_rtos
    ../FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS-Kernel/portable/RVDS/ARM_CM0/: port.c
    ../FreeRTOS-Kernel/portable/MemMang/: heap_3.c
software components: CMSIS:CORE 5.6.0
